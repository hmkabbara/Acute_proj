# IAR project SPM_Project2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FS7G27H Renesas R7FS7G27H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: src; src/synergy_gen; synergy/ssp/inc; synergy/ssp/inc/bsp; synergy/ssp/inc/bsp/cmsis/Include; synergy/ssp/inc/driver/api; synergy/ssp/inc/driver/instances; synergy/ssp/inc/framework/api; synergy/ssp/inc/framework/el; synergy/ssp/inc/framework/instances; synergy/ssp/src/framework/el/tx; synergy_cfg/ssp_cfg/bsp; synergy_cfg/ssp_cfg/driver; synergy_cfg/ssp_cfg/framework; synergy_cfg/ssp_cfg/framework/el
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SPM_Project2.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Synergy/Source Files/src
    src/: blinky_thread_entry.c cli.c cli.h cli_thread_entry.c hal_entry.c menu_builder.h MenuBuilder.c spm_fsm.c spm_fsm.h spm_fsm_leds.c spm_fsm_leds.h spm_fsm_thread0_entry.c uart_thread0_entry.c
  group Synergy/Source Files/src/synergy_gen
    src/synergy_gen/: blinky_thread.c blinky_thread.h cli_thread.c cli_thread.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c spm_fsm_thread0.c spm_fsm_thread0.h uart_thread0.c uart_thread0.h
  group Synergy/Source Files/synergy/board/s7g2_sk
    synergy/board/s7g2_sk/: bsp.h bsp_ethernet_phy.h bsp_init.c bsp_init.h bsp_leds.c bsp_leds.h bsp_qspi.c bsp_qspi.h
  group Synergy/Source Files/synergy/ssp/inc
    synergy/ssp/inc/: ssp_common_api.h ssp_features.h ssp_version.h
  group Synergy/Source Files/synergy/ssp/inc/bsp
    synergy/ssp/inc/bsp/: bsp_api.h
  group Synergy/Source Files/synergy/ssp/inc/bsp/cmsis/Include
    synergy/ssp/inc/bsp/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h core_cm23.h core_cm4.h mpu_armv7.h tz_context.h
  group Synergy/Source Files/synergy/ssp/inc/driver/api
    synergy/ssp/inc/driver/api/: r_cgc_api.h r_elc_api.h r_external_irq_api.h r_fmi_api.h r_ioport_api.h r_transfer_api.h r_uart_api.h
  group Synergy/Source Files/synergy/ssp/inc/driver/instances
    synergy/ssp/inc/driver/instances/: r_cgc.h r_dtc.h r_elc.h r_fmi.h r_icu.h r_ioport.h r_sci_uart.h
  group Synergy/Source Files/synergy/ssp/inc/framework/api
    synergy/ssp/inc/framework/api/: sf_comms_api.h
  group Synergy/Source Files/synergy/ssp/inc/framework/el
    synergy/ssp/inc/framework/el/: tx_api.h tx_cmsis.h tx_initialize.h tx_port.h tx_trace.h
  group Synergy/Source Files/synergy/ssp/inc/framework/el/cm4_iar
    synergy/ssp/inc/framework/el/cm4_iar/: tx_port.h
  group Synergy/Source Files/synergy/ssp/inc/framework/instances
    synergy/ssp/inc/framework/instances/: sf_uart_comms.h
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Include
    synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Include/: S7G2.h system_S7G2.h
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Source
    synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Source/: startup_S7G2.c system_S7G2.c
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/DSP_Lib/cm4_iar
    synergy/ssp/src/bsp/cmsis/DSP_Lib/cm4_iar/: libDSP_Lib.a
  group Synergy/Source Files/synergy/ssp/src/bsp/mcu/all
    synergy/ssp/src/bsp/mcu/all/: bsp_clocks.h bsp_common.c bsp_common.h bsp_common_analog.h bsp_common_leds.c bsp_common_leds.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_error_checking.h bsp_feature.h bsp_group_irq.h bsp_irq.c bsp_irq.h bsp_locking.c bsp_locking.h bsp_mcu_api.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c
  group Synergy/Source Files/synergy/ssp/src/bsp/mcu/s7g2
    synergy/ssp/src/bsp/mcu/s7g2/: bsp_analog.h bsp_cache.c bsp_cache.h bsp_clocks.c bsp_elc.h bsp_feature.c bsp_fmi_R7FS7G27H3A01CFC.c bsp_group_irq.c bsp_hw_locks.c bsp_mcu_info.h bsp_module_stop.c bsp_rom_registers.c
  group Synergy/Source Files/synergy/ssp/src/driver/r_cgc
    synergy/ssp/src/driver/r_cgc/: r_cgc.c r_cgc_private.h r_cgc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_cgc/hw
    synergy/ssp/src/driver/r_cgc/hw/: hw_cgc.h hw_cgc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dtc
    synergy/ssp/src/driver/r_dtc/: r_dtc.c r_dtc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dtc/hw
    synergy/ssp/src/driver/r_dtc/hw/: hw_dtc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dtc/hw/common
    synergy/ssp/src/driver/r_dtc/hw/common/: hw_dtc_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc
    synergy/ssp/src/driver/r_elc/: r_elc.c r_elc_private.h r_elc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc/hw
    synergy/ssp/src/driver/r_elc/hw/: hw_elc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc/hw/common
    synergy/ssp/src/driver/r_elc/hw/common/: hw_elc_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi
    synergy/ssp/src/driver/r_fmi/: r_fmi.c
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi/hw
    synergy/ssp/src/driver/r_fmi/hw/: hw_fmi_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi/hw/common
    synergy/ssp/src/driver/r_fmi/hw/common/: hw_fmi_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu
    synergy/ssp/src/driver/r_icu/: r_icu.c r_icu_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu/hw
    synergy/ssp/src/driver/r_icu/hw/: hw_icu_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu/hw/common
    synergy/ssp/src/driver/r_icu/hw/common/: hw_icu_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_ioport
    synergy/ssp/src/driver/r_ioport/: r_ioport.c r_ioport_private.h r_ioport_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_ioport/hw
    synergy/ssp/src/driver/r_ioport/hw/: hw_ioport_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_sci_uart
    synergy/ssp/src/driver/r_sci_uart/: r_sci_uart.c r_sci_uart_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_sci_uart/hw
    synergy/ssp/src/driver/r_sci_uart/hw/: hw_sci_common.h hw_sci_uart_private.h
  group Synergy/Source Files/synergy/ssp/src/framework/el/tx/cm4_iar
    synergy/ssp/src/framework/el/tx/cm4_iar/: libtx.a
  group Synergy/Source Files/synergy/ssp/src/framework/sf_uart_comms
    synergy/ssp/src/framework/sf_uart_comms/: sf_uart_comms.c sf_uart_comms_private.h sf_uart_comms_private_api.h
